# Keil uVision project SP_SENTRY.uvprojx, settings and files
target SP_SENTRY (6140001::V6.14.1::ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SP_SENTRY +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --text -a -c --output=@L.asm "!L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F427xx,STM32F427_437xx,USE_STDPERIPH_DRIVER,MPU6500,ARM_MATH_CM4,SP
  c include: ..\STMLib;..\STMLib\CMSIS\Include;..\STMLib\STM32F4xx_StdPeriph_Driver\inc;..\STMLib\STM32_USB_OTG_Driver\inc;..\STMLib\STM32_USB_HOST_Library\Core\inc;..\STMLib\STM32_USB_Device_Library\Core\inc;..\STMLib\STM32_USB_Device_Library\Class\cdc\inc;..\SPLib;..\SPLib\BSP;..\SPLib\AAL;..\SPLib\APP;..\SPLib\USB;..\SPLib\Mod\imu;..\SPLib\Mod\lqr;..\User;..\User\Config;..\SPLib\mod\View2MCU_ComProtocal;..\SPLib\Mod\chasis;..\SPLib\Mod\tof;..\SPLib\Core;..\SPLib\Mod\infrared;..\SPLib\USB\usr;..\SPLib\USB\hid;..\SPLib\Mod\referee;..\SPLib\Mod\sentry
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c sp_task.c
  group APP
    ../SPLib/APP/: sp_utility.c sp_motor.c sp_rc.c sp_shoot.c gimbal.c sp_irq.c
    ../SPLib/Mod/chasis/: sp_chasis.c
    ../SPLib/Mod/sentry/: sp_sentry.c
  group AAL
    ../SPLib/AAL/: sp_math.c sp_pid.c sp_filter.c
  group BSP
    ../SPLib/ASM/: sp_delay.s
    ../SPLib/BSP/: sp_spi.c sp_usart.c sp_gpio.c sp_dma.c sp_can.c sp_timer.c sp_rng.c sp_watchdog.c
    ../SPLib/Mod/imu/: imu_kalman[DSP].c sp_imu.c
  group View
    ../SPLib/Mod/View2MCU_ComProtocal/: Auto_aim.c frame.c
  group USB
    ../SPLib/: SP19_USB.lib
    ../SPLib/USB/hid/: usbd_desc.c usbd_hid_core.c
    ../SPLib/USB/usr/: usb.c usb_bsp.c usbd_usr.c
  group CORE
    ../STMLib/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../STMLib/: STM32F427_StdPeriph_Driver.lib
    ../SPLib/Core/: system_stm32f427II.c startup_stm32f427II.S
  group DOC
    ../SPLib/: DMA_Channels.md MPU6050_RegDesc.md MPU6500_Desc.md
  group TOF
    ../SPLib/Mod/tof/: i2c.c sp_sensor.c
  group infrared
    ../SPLib/Mod/infrared/: infrared.c
  group Referee
    ../SPLib/Mod/referee/: referee.c referee_crc.c
