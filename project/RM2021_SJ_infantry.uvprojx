# Keil uVision project RM2021_SJ_infantry.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2019_INFANTRY
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM
  c include: ..\CORE;..\Lib\inc;..\Lib\src;..\USER;..\Lib\SP_Lib;..\Lib\CMSIS\Include;..\HARDWARE\BSP;..\HARDWARE\BUZZER;..\HARDWARE\CAN;..\HARDWARE\DELAY;..\HARDWARE\LED;..\HARDWARE\RC;..\HARDWARE\SYS;..\HARDWARE\TIMER;..\HARDWARE\SPI;..\CONTROLTASK;..\APP\MONITOR;..\APP\REMOTECONTROL;..\APP\SP_KALMAN;..\HARDWARE\ADI_GYRO;..\APP\GIMBALCONTROL;..\APP\SP_MADGWICK;..\APP\sp_kalman_2;..\HARDWARE\JY901_USART;..\HARDWARE\UART3;..\APP\CMCONTROL;..\APP\PID;..\USER;..\APP\EULER;..\APP\SHOOTCONTROL;..\APP\REFEREEINFO;..\HARDWARE\UART6;..\HARDWARE\LASER;..\HARDWARE\UART2;..\HARDWARE\View2MCU_ComProtocal;..\APP\AUTOMATIC_AIM;..\HARDWARE\MPU6500;..\HARDWARE\View2MCU_ComProtocal;..\APP\CAPCONTROL;..\HARDWARE\USB;..\Lib\STM32_USB_OTG_Driver\inc;..\Lib\STM32_USB_Device_Library\Core\inc;..\Lib\STM32_USB_Device_Library\Class\cdc\inc;..\Lib\STM32_USB_HOST_Library\Core\inc;..\HARDWARE\USB\usr;..\HARDWARE\USB\hid;..\APP\SEND_COMP;..\APP\FRICTIONCONTROL;..\APP\FeedControl;..\HARDWARE\UART8
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../USER/: main.c system_stm32f4xx.c stm32f4xx_it.c
  group lib
    ../Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group core
    ../CORE/: startup_stm32f40_41xxx.s
  group hardware
    ../HARDWARE/BSP/: bsp.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/BUZZER/: buzzer.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/DELAY/: delay.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RC/: rc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADI_GYRO/: adi_gyro.c
    ../HARDWARE/UART2/: usart2.c
    ../HARDWARE/UART3/: usart3.c
    ../HARDWARE/UART6/: usart6.c
    ../HARDWARE/MPU6500/: mpu6500.c
    ../HARDWARE/LASER/: laser.c
    ../HARDWARE/UART8/: uart8.c
  group app
    ../APP/MONITOR/: MonitorControl.c
    ../APP/REMOTECONTROL/: RemoteControl.c
    ../APP/GIMBALCONTROL/: GimbalControl.c
    ../APP/CMCONTROL/: CMControl.c
    ../APP/EULER/: euler.c
    ../APP/AUTOMATIC_AIM/: Auto_aim.c
    ../APP/REFEREEINFO/: RefereeInfo.c
    ../APP/CAPCONTROL/: cap_control.c
    ../APP/SEND_COMP/: SendCom.c
    ../APP/FeedControl/: FeedControl.c
    ../APP/FRICTIONCONTROL/: FrictionControl.c
  group task
    ../CONTROLTASK/: ControlTask.c
  group SP_Lib
    ../Lib/SP_Lib/: sp_math.c sp_pid.c sp_filter.c
  group usb
    ../HARDWARE/USB/usr/: usb.c usb_bsp.c usbd_usr.c
    ../HARDWARE/USB/hid/: usbd_desc.c usbd_hid_core.c
    ../HARDWARE/USB/: SP19_USB.lib
